do_deploy_append() {
     echo "device_tree=bcm2837-rpi-3-b.dtb" >> ${DEPLOYDIR}/bootfiles/config.txt
}
